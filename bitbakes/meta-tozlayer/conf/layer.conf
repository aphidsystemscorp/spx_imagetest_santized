## bitbakes/meta-tozlayer/conf/layer.conf
```bitbake
PREFERRED_PROVIDER_virtual/egl = "gles-user-module"
BBFILE_PRIORITY_meta-tozlayer = "10"
IMAGE_INSTALL_remove += " mesa-gl "
```
